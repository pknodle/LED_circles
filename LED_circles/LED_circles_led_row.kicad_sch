File: LED_circles/LED_circles_led_row.kicad_sch (KiCad schematic)
At the start: 16 parts

Commit message: WIP
Parts:
- U1, U10, U11, U12, U13, U2, U4, U5, U6, U7, U8, U9: value ~ -> (none)
